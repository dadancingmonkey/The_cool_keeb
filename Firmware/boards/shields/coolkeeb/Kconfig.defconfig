## Firmware/boards/shields/coolkeeb/Kconfig.defconfig
```kconfig
if SHIELD_COOLKEEB

config ZMK_KEYBOARD_NAME
    default "coolkeeb"

endif # SHIELD_COOLKEEB
```
